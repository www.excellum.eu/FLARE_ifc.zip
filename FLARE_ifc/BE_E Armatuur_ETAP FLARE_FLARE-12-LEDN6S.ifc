Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-06-15T12:12:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160525_1230(x64) - Exporter 16.0.1144.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 15 12:12:51 2016 * Host: gebruiker-PC * Database: C:\Users\GEBRUI~1\AppData\Local\Temp\{9502C3F6-E384-4A2D-96EF-44C42B8CF4B8}\ifc * Database version: 5507 * Database creation date: Wed Jun 15 12:12:50 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 15 12:12:51 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 15 12:12:51 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: FLARE-12-LEDN6S, Dummy:FLARE-12-LEDN6S:226972
In: Level 1
Type - Material: Glass, BE_G Reflector, BE_G Glas lamp, BE Armatuur
Type - Constraints - Default Elevation: 1000 mm; WT_H Behuizing: 1.LED.6; WT_H Breedte: 98 mm; WT_H Coarse geometrie: Standaard; WT_H Einde void: -63 mm; WT_H Grid_breedte: 300 mm; WT_H Grid_lengte: 1200 mm; WT_H Halve breedte negatief: -49 mm; WT_H Halve hoogte: 31.5 mm; WT_H Halve hoogte negatief: -31.5 mm; WT_H Halve hoogte symbool: 49 mm; WT_H Halve lengte: 49 mm; WT_H Halve lengte negatief: -49 mm; WT_H Hoogte: 63 mm; WT_H Inbouw: yes; WT_H Inbouwdiepte: 63 mm; WT_H Lengte: 98 mm; WT_H Opliggende boord: yes; WT_H Richtbaar: no; WT_H Symbool plafond hoogte: 98 mm; WT_H Symbool plafond lengte: 98 mm; WT_H Symbool straal: 49 mm; WT_H Symbool wand hoogte: 63 mm; WT_H Symbool wand lengte: 98 mm; WT_H Uitsnijding_diameter: 81 mm; WT_H Uitsteek: 0 mm; WT_H Vlakke boord: no
Type - Dimensions - BE_G Breedte: 98 mm; BE_G Diameter: 98 mm; BE_G Hoogte: 63 mm; BE_G Lengte: 98 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 9 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 9 W
Type - Graphics - WT_V Symbool plafond: Ronde armatuur; WT_V Symbool wand: Geen
Type - Identity Data - BE_I Bestelcode: FLARE-12/LEDN6S; Manufacturer: ETAP; Model: FLARE; Type Name: FLARE-12-LEDN6S; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - WT_V Materiaal armatuur: BE Armatuur
Type - Model Properties - WT_I Armatuurrendement: 1; WT_I Dimbaar: Nee; WT_I IP klasse: -; WT_I Kleur: behuizing uit gegoten aluminium RAL9003-wit, ledmodule in RAL9005-zwart; WT_I Maatschets catalogus: 2045; WT_I Maximale temperatuur: -; WT_I Montage: Inbouw; WT_I Optiek: spot; WT_I UGR: -; WT_I Uitsnijding: Ø 81; WT_I Voorschakelapparaat: S; WT_I Vorm: downlight
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP FLARE - lichtbron: FLARE-12_LEDN6_S; WT_I Aantal lampen: 4; WT_I Lamptype: High PowerLed; WT_I Lichtverdeling: diepstralend; WT_I Luminantie: 0; WT_I Vermogen lamp: 6 W
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: FLARE-12-LEDN6S
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Optiek_hoek: 0 deg; WT_H Uitsnijding_straal: 40.5 mm
Construction - WT_V Optiek_hoek: 0 deg
Dimensions - Area: 0.0370362 m2; Volume: 0.000890866 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-9 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 75
Other - Family: Dummy: FLARE-12-LEDN6S; Family and Type: Dummy: FLARE-12-LEDN6S; Schedule Level: Level: Level 1; Type: Dummy: FLARE-12-LEDN6S; Type Id: Dummy: FLARE-12-LEDN6S
Phasing - Phase Created: 469492
